options:
  parameters:
    author: Alex Brisson
    generate_options: qt_gui
    id: usrp_sdrbasics
    output_language: python
    title: Basics of SDRs and IQ
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: excessbw
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      Random Integer Generator- 
      generates random integers bound
      to 0 and 1.
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: analog_random_uniform_source_x_0_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      Random Integer Generator- 
      generates random integers bound
      to 0 and 1.
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    comment: |-
      Repeat each symbol 
      'sps' times
    interp: sps
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: int(log2(constellation.arity()))
    comment: |-
      Each integer from the RUS is converted into a byte. 
      This block packs the last bits in each integer byte 
      into a new "packed" byte to be transmitted.
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      Multiplies the carrier by 
      +1 or -1 (BPSK)
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,+1)
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'False'
    excess_bw: excessbw
    samples_per_symbol: sps
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import log2
  states: {}
- name: note_0
  id: note
  parameters:
    note: Lab 1 Part 1
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Lab 1 Part 2
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Lab 1 Part 3
  states: {}
- name: note_1
  id: note
  parameters:
    note: set fs = 500k
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: fc = 10M
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: set fs = 1M
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    label1: Real Part (I)
    label2: Imaginary Part (Q)
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: 'IQ Tx Square Pulse '
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: 'IQ Tx Square Pulse '
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: IQ Rx Spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: IQ Rx Spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    label1: 'Tx- Real Part (I) '
    label2: Tx- Imaginary Part (Q)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    label1: 'Tx- Real Part (I) '
    label2: Tx- Imaginary Part (Q)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Rx- Real Part (I)
    label2: Rx- Imaginary Part (Q)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Rx- Real Part (I)
    label2: Rx- Imaginary Part (Q)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excessbw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    comment: USRP Transmiter
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    comment: USRP Transmiter
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    comment: USRP Receiver
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq+100e3
    comment: USRP Receiver
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    comment: Sinusoids and Complex DC
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [analog_random_uniform_source_x_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_repeat_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_repeat_0_0, '0', uhd_usrp_sink_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_repeat_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1_0, '0']
- [uhd_usrp_source_0_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
